# Keil uVision project GaInOS.uvproj, settings and files
target GaInOS (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: GaInOS +hex
  AfterMake: fromelf.exe --bin -o @p.bin obj/@p.axf
  c flags: Optim=3 oTime=1
  c include: ..\Bsp\Cpu;..\Bsp\Serial;..\vPort;..\..\..\include;..\..\..\kernel;..\..\..\osek_test\GaInOS_Studio;D:\usr\opt\keil\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x2000000
  memory RVCT6: RAM 0x31000000 size 0x4000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: .\script\runinFlash.sct
  group boot
    ../vPort/: start_rvds.S vPort.c vPort_Rvds.S
  group kernel
    ../../../kernel/: Alarm.c Autosar.c Event.c Hooks.c Interrupt.c Osctrl.c Resource.c Task.c Counter.c SchedTbl.c
  group main
    ./Source/: main.c
  group bsp
    ../Bsp/Cpu/: Cpu.c
    ../Bsp/Serial/: Serial.c
  group cfg
    ../../../osek_test/GaInOS_Studio/: CfgObj.c CfgRdyQ.c CfgSchedTbl.c
