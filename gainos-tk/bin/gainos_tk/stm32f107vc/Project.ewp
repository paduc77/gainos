# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\include; ..\..\..\arch\stm32f1; ..\..\..\arch\stm32f1\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\arch\stm32f1\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\osek\inc; ..\..\..\osek\portable\armv7_m; ..\..\..\comstack\CanTp; ..\..\..\comstack\Com; ..\..\..\comstack\CanIf; ..\..\..\comstack\PduR; ..\..\..\ecual\EcuM; ..\..\..\mcal\driver\Can; ..\..\..\mcal\driver\Can\sysdepend\stm32f1; ..\..\..\diag\Det; ..\..\..\diag\Dem; ..\..\..\diag\Dcm; ..\..\..\memory\NvM
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\osek\portable\armv7_m; ..\..\..\arch\stm32f1
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group GaInOS/app
    ../../../app/: app.c
  group GaInOS/arch
    ../../../arch/stm32f1/: Compiler.h Platform_Types.h
  group GaInOS/arch/Libraries/CMSIS
    ../../../arch/stm32f1/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group GaInOS/arch/Libraries/CMSIS/startup
    ../../../arch/stm32f1/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group GaInOS/arch/Libraries/StdPeriph/inc
    ../../../arch/stm32f1/Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_can.h stm32f10x_conf.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_usart.h
  group GaInOS/arch/Libraries/StdPeriph/src
    ../../../arch/stm32f1/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group GaInOS/comstack/CanIf
    ../../../comstack/CanIf/: CanIf.c CanIf.h CanIf_Cbk.h CanIf_ConfigTypes.h CanIf_Types.h
  group GaInOS/comstack/CanTp
    ../../../comstack/CanTp/: CanTp.c CanTp.h CanTp_Cbk.h CanTp_Types.h SchM_CanTp.h
  group GaInOS/comstack/Com
    ../../../comstack/Com/: Com.c Com.h Com_Arc_Types.h Com_Cbk.h Com_Com.c Com_Com.h Com_Internal.h Com_misc.c Com_misc.h Com_Sched.c Com_Sched.h Com_Types.h ComStack_Types.h
  group GaInOS/comstack/PduR
    ../../../comstack/PduR/: PduR.c PduR.h PduR_CanIf.c PduR_CanIf.h PduR_CanTp.c PduR_CanTp.h PduR_Com.c PduR_Com.h PduR_Dcm.c PduR_Dcm.h PduR_If.h PduR_J1939Tp.c PduR_J1939Tp.h PduR_LinIf.c PduR_LinIf.h PduR_Logic.c PduR_Routing.c PduR_SoAd.c PduR_SoAd.h PduR_Types.h
  group GaInOS/config
    ../../../config/: Can_Cfg.h Can_PBcfg.c CanIf_Cfg.c CanIf_Cfg.h CanTp_Cfg.c CanTp_Cfg.h Com_Cfg.h Com_PbCfg.c Com_PbCfg.h Dcm_Cfg.h Dcm_LCfg.c Dem_Cfg.h Dem_IntErrId.h Dem_IntEvtId.h Dem_LCfg.c NvM_Cfg.h osek_cfg.c osek_cfg.h PduR_Cfg.h PduR_PbCfg.c PduR_PbCfg.h
  group GaInOS/diag/Dcm
    ../../../diag/Dcm/: Dcm.c Dcm.h Dcm_Callout_Stubs.c Dcm_Cbk.h Dcm_Dsd.c Dcm_Dsl.c Dcm_Dsp.c Dcm_Internal.h Dcm_Lcfg.h Dcm_Types.h Rte_Dcm.h
  group GaInOS/diag/Dem
    ../../../diag/Dem/: Dem.h Dem_Types.h
  group GaInOS/diag/Det
    ../../../diag/Det/: Det.c Det.h
  group GaInOS/ecual/EcuM
    ../../../ecual/EcuM/: EcuM.h EcuM_Cbk.h EcuM_Types.h
  group GaInOS/include
    ../../../include/: Cpu.h Debug.h Modules.h Os.h Std_Types.h
  group GaInOS/mcal/Can
    ../../../mcal/driver/Can/: Can.c Can.h Can_Types.h
    ../../../mcal/driver/Can/sysdepend/stm32f1/: Can_Hw.c Can_Hw.h
  group GaInOS/memory/NvM
    ../../../memory/NvM/: NvM.h NvM_Cbk.h NvM_ConfigTypes.h NvM_Types.h
  group GaInOS/osek/inc
    ../../../osek/inc/: knl_alarm.h knl_bitop.h knl_event.h knl_queue.h knl_resource.h knl_task.h knl_timer.h knl_wait.h osek_check.h osek_os.h
  group GaInOS/osek/portable/armv7_m
    ../../../osek/portable/armv7_m/: portable.c portable.h portmacro.h
  group GaInOS/osek/portable/armv7_m/icc
    ../../../osek/portable/armv7_m/icc/: portableS.S
  group GaInOS/osek/src
    ../../../osek/src/: knl_alarm.c knl_bitop.c knl_misc.c knl_task.c knl_timer.c knl_wait.c osek_alarm.c osek_counter.c osek_event.c osek_interrupt.c osek_osctrl.c osek_resource.c osek_task.c
