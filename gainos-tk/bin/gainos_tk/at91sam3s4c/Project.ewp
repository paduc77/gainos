# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sam3s4; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\include; ..\..\..\arch\at91sam3s; ..\..\..\arch\at91sam3s\libraries\libchip_sam3s; ..\..\..\arch\at91sam3s\libraries\libchip_sam3s\include; ..\..\..\arch\at91sam3s\libraries\libboard_sam3s-ek; ..\..\..\arch\at91sam3s\libraries\libboard_sam3s-ek\include; ..\..\..\osek\inc; ..\..\..\osek\portable\armv7_m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\osek\portable\armv7_m; ..\..\..\arch\at91sam3s; ..\..\..\config
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group app
    ../../../app/: app.c
  group arch
    ../../../arch/at91sam3s/: Compiler.h Platform_Types.h
  group arch/libraries/libboard_sam3s-ek
    ../../../arch/at91sam3s/libraries/libboard_sam3s-ek/: board.h
  group arch/libraries/libboard_sam3s-ek/include
    ../../../arch/at91sam3s/libraries/libboard_sam3s-ek/include/: clock.h uart_console.h
  group arch/libraries/libboard_sam3s-ek/source
    ../../../arch/at91sam3s/libraries/libboard_sam3s-ek/source/: board_lowlevel.c clock.c uart_console.c
  group arch/libraries/libchip_sam3s
    ../../../arch/at91sam3s/libraries/libchip_sam3s/: chip.h
  group arch/libraries/libchip_sam3s/include
    ../../../arch/at91sam3s/libraries/libchip_sam3s/include/: SAM3S.h
  group arch/libraries/libchip_sam3s/source
    ../../../arch/at91sam3s/libraries/libchip_sam3s/source/: pio.c pmc.c usart.c wdt.c
  group config
    ../../../config/: osek_cfg.c osek_cfg.h
  group include
    ../../../include/: Cpu.h Debug.h Modules.h Os.h Std_Types.h
  group osek/inc
    ../../../osek/inc/: knl_alarm.h knl_bitop.h knl_event.h knl_queue.h knl_resource.h knl_task.h knl_timer.h knl_wait.h osek_check.h osek_os.h
  group osek/portable/armv7_m
    ../../../osek/portable/armv7_m/: portable.c portable.h portmacro.h
  group osek/portable/armv7_m/icc
    ../../../osek/portable/armv7_m/icc/: portableS.S startup.S
  group osek/src
    ../../../osek/src/: knl_alarm.c knl_bitop.c knl_misc.c knl_task.c knl_timer.c knl_wait.c osek_alarm.c osek_counter.c osek_event.c osek_interrupt.c osek_osctrl.c osek_resource.c osek_task.c
