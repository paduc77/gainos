# IAR project autosar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _APP_STM32F1_; _CHIP_STM32F107VC_; CPU_ARMV7_M; STM32F10X_CL; MICRO_TENUX_VERSION=150
  ICCARM.CCIncludePath2: ../../common/tm_printf; ../../comstack/CanIf; ../../comstack/CanTp; ../../comstack/Com; ../../comstack/PduR; ../../config; ../../diag/Dem; ../../diag/Det; ../../ecual/EcuM; ../../mcal/arch/stm32f1; ../../mcal/arch/stm32f1/cm3; ../../mcal/arch/stm32f1/STM32F10x_StdPeriph_Driver/inc; ../../include; ../../mcal/driver/Can; ../../mcal/driver/Can/sysdepend/stm32f1; ../../osek/src; ../../../kernel/src; ../../../include; ../../../config; ../../../kernel\src\sysdepend\armv7_m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: autosar.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group build
    ./: autosar.ewp
  group common/tm_printf
    ../../common/tm_printf/: tm_printf.c tm_printf.h
  group comstack/CanIf
    ../../comstack/CanIf/: CanIf.c CanIf.h CanIf_Cbk.h CanIf_ConfigTypes.h CanIf_Types.h
  group comstack/CanTp
    ../../comstack/CanTp/: CanTp.c CanTp.h CanTp_Cbk.h CanTp_Types.h SchM_CanTp.h
  group comstack/Com
    ../../comstack/Com/: Com.c Com.h Com_Arc_Types.h Com_Cbk.h Com_Com.c Com_Com.h Com_Internal.h Com_misc.c Com_misc.h Com_Sched.c Com_Sched.h Com_Types.h ComStack_Types.h
  group comstack/PduR
    ../../comstack/PduR/: PduR.c PduR.h PduR_CanIf.c PduR_CanIf.h PduR_CanTp.c PduR_CanTp.h PduR_Com.c PduR_Com.h PduR_Dcm.c PduR_Dcm.h PduR_If.h PduR_J1939Tp.c PduR_J1939Tp.h PduR_LinIf.c PduR_LinIf.h PduR_Logic.c PduR_Routing.c PduR_SoAd.c PduR_SoAd.h PduR_Types.h
  group config
    ../../config/: Can_Cfg.h Can_PBCfg.c CanIf_Cfg.c CanIf_Cfg.h CanTp_Cfg.c CanTp_Cfg.h Com_CalloutNotification.c Com_Cfg.h Com_PbCfg.c Com_PbCfg.h osek_cfg.c osek_cfg.h PduR_Cfg.h PduR_PbCfg.c PduR_PbCfg.h
  group diag/Dem
    ../../diag/Dem/: Dem.h Dem_IntErrId.h
  group diag/Det
    ../../diag/Det/: Det.c Det.h
  group ecual/EcuM
    ../../ecual/EcuM/: EcuM.h EcuM_Cbk.h EcuM_Types.h
  group include
    ../../include/: ardebug.h Cpu.h Modules.h Std_Types.h
  group mcal/arch
    ../../mcal/arch/stm32f1/: Platform_Types.h
  group mcal/arch/cm3
    ../../mcal/arch/stm32f1/cm3/: stm32f10x.h
  group mcal/arch/STM32F10x_StdPeriph_Driver/inc
    ../../mcal/arch/stm32f1/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_can.h stm32f10x_rcc.h
  group mcal/arch/STM32F10x_StdPeriph_Driver/src
    ../../mcal/arch/stm32f1/STM32F10x_StdPeriph_Driver/src/: stm32f10x_can.c stm32f10x_rcc.c
  group mcal/driver/Can
    ../../mcal/driver/Can/: Can.c Can.h Can_Types.h
  group mcal/driver/Can/sysdepend
    ../../mcal/driver/Can/sysdepend/stm32f1/: Can_Hw.c Can_Hw.h
  group osek
    ../../osek/src/: osek_alarm.c osek_check.h osek_counter.c osek_event.c osek_interrupt.c osek_os.h osek_osctrl.c osek_resource.c osek_task.c
